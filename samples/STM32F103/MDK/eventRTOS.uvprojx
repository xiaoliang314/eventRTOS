# Keil uVision project eventRTOS.uvprojx, settings and files
target eventRTOS (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eventRTOS
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group kernel
    ../../../kernel/: kevent.c kslab_mem.c ktask_co.c ktimer.c
  group drivers
    ../../../drivers/timer/: cortex_m_systick.c
  group arch
    ../../../arch/cortex-m/armcc/: preempt_nofp.s
  group user
    ../: main.c timer_port.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
